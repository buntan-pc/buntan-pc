# Repository buntan-pc/buntan-pc (continued)

## KiCad design board/pc_rev2/pcb/pc_rev2.kicad_pcb (continued)

Parts:
U1: Tang_nano_9K; DIP-48_Tang-Nano-9K
U7: Tang_nano_20K; DIP-40_Tang-Nano-20K; not fitted

Connections:
+3.3V: U1.25 (3V3), U7.19 (3V3), U7.25 (3V3); also elsewhere on the board
+5V: U1.31 (5V), U7.40 (5V); also elsewhere on the board
/ADC/cmp: U1.14 (PIN35_IOB29A), U7.38 (PIN76_IOT30B); also elsewhere on the board
/ADC/sel0: U1.15 (PIN41_IOB41A), U7.1 (PIN73_IOT40A); also elsewhere on the board
/ADC/sel1: U1.16 (PIN42_IOB41B), U7.2 (PIN74_IOT34B); also elsewhere on the board
/ADC/sel2: U1.17 (PIN51_IOR17B), U7.3 (PIN75_IOT34A); also elsewhere on the board
/ADC/sh_on: U1.13 (PIN40_IOB33B), U7.28 (PIN86_IOT4A); also elsewhere on the board
/ADC/vref_d0: U1.5 (PIN25_IOB8A), U7.5 (PIN77_IOT30A); also elsewhere on the board
/ADC/vref_d1: U1.6 (PIN26_IOB8B), U7.8 (PIN27_IOB8A); also elsewhere on the board
/ADC/vref_d2: U1.7 (PIN27_IOB11A), U7.9 (PIN28_IOB8B); also elsewhere on the board
/ADC/vref_d3: U1.8 (PIN28_IOB11B), U7.10 (PIN25_IOB6A); also elsewhere on the board
/ADC/vref_d4: U1.9 (PIN29_IOB13A), U7.11 (PIN26_IOB6B); also elsewhere on the board
/ADC/vref_d5: U1.10 (PIN30_IOB13B), U7.12 (PIN29_IOB14A); also elsewhere on the board
/ADC/vref_d6: U1.11 (PIN33_IOB23A), U7.13 (PIN30_IOB14B); also elsewhere on the board
/ADC/vref_d7: U1.12 (PIN34_IOB23B), U7.14 (PIN31_IOB29A); also elsewhere on the board
/audio/spk_on: U1.18 (PIN53_IOR15B), U7.32 (PIN51_IOR45A); also elsewhere on the board
/beep: U1.36 (PIN74_IOT38B), U7.23 (PIN71_IOT44A); also elsewhere on the board
/mcu/dbgio0: U1.39 (PIN77_IOT37A), U7.34 (PIN56_IOR36A); also elsewhere on the board
/mcu/dbgio1: U1.38 (PIN76_IOT37B), U7.33 (PIN54_IOR38A); also elsewhere on the board
/mcu/dbgio2: U1.28 (PIN31_IOB15A), U7.30 (PIN55_IOR36B); also elsewhere on the board
/mcu/gpio0: U1.23 (PIN68_IOT42B), U7.6 (PIN15_IOL47A); also elsewhere on the board
/mcu/gpio1: U1.24 (PIN69_IOT42A), U7.7 (PIN16_IOL47B); also elsewhere on the board
/mcu/gpio2: U1.32 (PIN70_IOT41B), U7.15 (PIN17_IOL49A); also elsewhere on the board
/mcu/gpio3: U1.33 (PIN71_IOT41A), U7.18 (PIN18_IOL49B); also elsewhere on the board
/mcu/gpio4: U1.34 (PIN72_IOT39B), U7.17 (PIN19_IOL51A); also elsewhere on the board
/mcu/gpio5: U1.35 (PIN73_IOT39A), U7.16 (PIN20_IOL51B); also elsewhere on the board
/mcu/gpio7: U1.37 (PIN75_IOT38A), U7.24 (PIN72_IOT40B); also elsewhere on the board
/mcu/rgbled: U1.47 (PIN86_IOT8A), U7.27 (PIN79_IOT27B); also elsewhere on the board
/mcu/tf_cs: U1.1 (PIN38_IOB31B); also elsewhere on the board
/mcu/tf_miso: U1.4 (PIN39_IOB33A); also elsewhere on the board
/mcu/tf_mosi: U1.2 (PIN37_IOB31A); also elsewhere on the board
/mcu/tf_sclk: U1.3 (PIN36_IOB29B); also elsewhere on the board
/msmp_rx: U1.20 (PIN55_IOR14B), U7.36 (PIN42_IOB42B); also elsewhere on the board
/msmp_tx: U1.19 (PIN54_IOR15A), U7.35 (PIN41_IOB43A); also elsewhere on the board
/scl: U1.48 (PIN63_IOR5A), U7.22 (PIN53_IOR38B); also elsewhere on the board
/sda: U1.27 (PIN32_IOB15B), U7.21 (PIN52_IOR39A); also elsewhere on the board
/sericon_rx: U1.29 (PIN49_IOR24A), U7.29 (PIN49_IOR49A); also elsewhere on the board
/sericon_tx: U1.30 (PIN48_IOR24B), U7.31 (PIN48_IOR49B); also elsewhere on the board
/uart_rx: U1.22 (PIN57_IOR13A), U7.37 (PIN80_IOT27A); also elsewhere on the board
/uart_tx: U1.21 (PIN56_IOR14A), U7.4 (PIN85_IOT4B); also elsewhere on the board
GND: U1.26 (GND), U7.20 (GND), U7.26 (GND), U7.39 (GND); also elsewhere on the board

Notes on the sheet:
HDMI
1.8V
PIN番号共通
TF SPI TN9K TN20K -------------------- D3 CS PIN38 PIN81 CMD MOSI PIN37 PIN82 CLK SCLK PIN36 PIN83 D0 MISO PIN39 PIN84
オーディオ機能のためのピン（I2C_xとPA_EN） は面白そうなのでなるべく空けておきたい。 そのためデバッグ用ピンとする。

Board: 2 copper layers, 100.0 x 100.0 mm, 99 parts (0 on the bottom side), 92 nets.

## KiCad design sericon/board_rev1/board_rev1.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J2: 5075AR-04-WH; USB_A_Neltron_5075AR-04
J3: Conn_Grove_Dev; Grove_1x04_P2mm_THT_Horizontal
J4: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J5: Conn_01x24; PinHeader_1x24_P2.54mm_Vertical
J6: Conn_01x22; PinHeader_1x22_P2.54mm_Vertical
R1, R2: 15k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: Tang_nano_9K; DIP-48_Tang-Nano-9K

Connections:
+5V: J1.1 (VBUS), J2.1 (VBUS), J3.3 (VCC), J6.18, U1.31 (5V)
/scl: J5.13, U1.13 (PIN40_IOB33B)
/sda: J5.14, U1.14 (PIN35_IOB29A)
/uart2_rx: J5.16, U1.16 (PIN42_IOB41B)
/uart2_tx: J5.15, U1.15 (PIN41_IOB41A)
/uart3b_rx: J3.2 (TX), J6.20, U1.29 (PIN49_IOR24A)
/uart3b_tx: J3.1 (RX), J6.19, U1.30 (PIN48_IOR24B)
/uart_rx: J5.19, U1.19 (PIN54_IOR15A)
/uart_tx: J5.18, U1.18 (PIN53_IOR15B)
GND: J1.4 (GND), J1.5 (Shield), J2.4 (GND), J2.5 (Shield), J3.4 (GND), J4.1, J4.2, J4.3, J4.4, R1.2, R2.2, U1.26 (GND)
unnamed: J1.3 (D+), J6.10, R1.1, U1.39 (PIN77_IOT37A)
unnamed: J1.2 (D-), J6.11, R2.1, U1.38 (PIN76_IOT37B)
unnamed: J5.1, U1.1 (PIN38_IOB31B)
unnamed: J5.2, U1.2 (PIN37_IOB31A)
unnamed: J5.3, U1.3 (PIN36_IOB29B)
unnamed: J5.4, U1.4 (PIN39_IOB33A)
unnamed: J5.5, U1.5 (PIN25_IOB8A)
unnamed: J5.6, U1.6 (PIN26_IOB8B)
unnamed: J5.7, U1.7 (PIN27_IOB11A)
unnamed: J5.8, U1.8 (PIN28_IOB11B)
unnamed: J5.9, U1.9 (PIN29_IOB13A)
unnamed: J5.10, U1.10 (PIN30_IOB13B)
unnamed: J5.11, U1.11 (PIN33_IOB23A)
unnamed: J5.12, U1.12 (PIN34_IOB23B)
unnamed: J5.17, U1.17 (PIN51_IOR17B)
unnamed: J5.20, U1.20 (PIN55_IOR14B)
unnamed: J5.21, U1.21 (PIN56_IOR14A)
unnamed: J5.22, U1.22 (PIN57_IOR13A)
unnamed: J5.23, U1.23 (PIN68_IOT42B)
unnamed: J5.24, U1.24 (PIN69_IOT42A)
unnamed: J6.1, U1.48 (PIN63_IOR5A)
unnamed: J6.2, U1.47 (PIN86_IOT8A)
unnamed: J6.3, U1.46 (PIN85_IOT8B)
unnamed: J6.4, U1.45 (PIN84_IOT10A)
unnamed: J6.5, U1.44 (PIN83_IOT10B)
unnamed: J6.6, U1.43 (PIN82_IOT11A)
unnamed: J6.7, U1.42 (PIN81_IOT11B)
unnamed: J6.8, U1.41 (PIN80_IOT12A)
unnamed: J6.9, U1.40 (PIN79_IOT12B)
unnamed: J6.12, U1.37 (PIN75_IOT38A)
unnamed: J6.13, U1.36 (PIN74_IOT38B)
unnamed: J6.14, U1.35 (PIN73_IOT39A)
unnamed: J6.15, U1.34 (PIN72_IOT39B)
unnamed: J6.16, U1.33 (PIN71_IOT41A)
unnamed: J6.17, U1.32 (PIN70_IOT41B)
unnamed: J6.21, U1.28 (PIN31_IOB15A)
unnamed: J6.22, U1.27 (PIN32_IOB15B)

Notes on the sheet:
ADC
key_row
GroveのRX/TXは ホストからみた名前
LCD
key_col_n
キーボード用 USBコネクタ
HDMI
HDMIディスプレイ 電源供給用 USBコネクタ

Board: 2 copper layers, 60.0 x 80.0 mm, 13 parts (0 on the bottom side), 47 nets.

## Commit log (part)

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2024-11-01 プロジェクトの進め方やライセンス文書などを追加
2024-12-09 コードオーナーを uchan-nos に統一
    後からコードを書く人が増えたらその都度調整する
2024-12-25 OSC2025 Tokyo/Springに向けた開発目標を記載
2024-12-27 ComProcから一式をコピー
    BuntanPCの原型とするために、ComProcプロジェクトから
    コンパイラ、アセンブラ、OS、CPU、CPUボード、幾つかのツールをコピー。
2024-12-27 主要なコードの先頭に著作権表記を追加
2024-12-27 各コンポーネントをルートディレクトリへ移動
2024-12-27 スクリプトファイルに SPDX 識別子を追加
2024-12-27 DOSがLCDを使わないようにしてUARTに特化させる
2024-12-27 UART入力システムコールとサンプルアプリの追加
2025-01-06 Cコンパイラのバグを修正
    - 制御構文で余分な値がスタックに積まれたままになるバグ
    - switch文でdefaultラベルとbreakを使った場合のバグ
2025-01-06 戻り値無しの関数呼び出しで余分にpopされるバグを修正
2025-01-08 ポインタインクリメントのアドレス加算量のバグ修正
2025-01-08 ファイル読み込みシステムコールとサンプルアプリを追加
2025-01-09 ブロック書き込みシステムコールを追加
2025-01-10 ディレクトリエントリ書き込みのシステムコールを追加
2025-01-10 ファイルの新規作成や追記を試すアプリ fwrite を追加
2025-01-10 アプリがsyscall.hを使うようにする
2025-01-10 コマンドライン引数をアプリに渡す
2025-01-10 コマンド入力時にプロンプトを出す
2025-01-10 同じ値の文字列リテラルを 1 つにまとめる最適化
2025-01-15 UARTでアプリを受信する仕組みを追加
2025-01-16 配列の初期値が足りないときは残りを0で初期化する
2025-01-16 .dataのラベルが1つもない場合に.dataが0バイトになるバグを修正
2025-01-16 送信バイト列に0x55が入っていた場合に送信間隔を空ける
2025-01-20 テキストエディタを追加
2025-01-20 cat がアプリ用 DMEM 領域を壊さないようにする
2025-01-20 ファイル削除コマンド rm を追加
2025-01-20 hexファイルをpmemに転送するコマンドを新設
2025-01-21 DOS起動時にLCDにメッセージを表示＆IPL更新
2025-01-22 プログラムの規模拡大にアセンブラを対応
2025-01-22 UARTと同時にLCDとKBCを利用する
2025-01-22 LCD表示を右矢印に対応させる
2025-01-22 細かいバグ修正
2025-01-22 ラインエディタedを追加
    本家edのコマンドのごく一部のみサポート
2025-01-22 入出力先としてUARTとLCDを選択できるようにする
2025-02-12 IPLを最新化
2025-02-12 OSにキーのエスケープ処理をまかせる
2025-02-12 editをリファクタリング
2025-04-11 ucc: Add option --offset-global-addr
    アセンブラ側で先頭に pmem_len & dmem_len を追加する場合にオフセットが
    4 だけずれるのをコンパイラ側で補正するときに使う想定の仕組み。
2025-04-11 Import msmp.c from ComProc
2025-04-11 msmp.c を本文無しメッセージの送信に対応させる
2025-04-25 Add kuas assembler, an alternative to uas.
2025-04-25 Update kuas.c - kuas04a相当に更新
    エラー処理改善
    コードを整理
2025-05-07 Update kuas.c - kuas05a相当に更新
2025-08-26 キッチンタイマーアプリを追加
2025-09-27 I2C ディスプレイ制御サンプルを追加
2025-09-27 VCOMが接続できないバグに対応
    WSL2のバージョンが上がったのか、ftdi_sioドライバでは対応できなくなった。
    調査の結果vhci_hcdドライバをロードしたら解決できた。
    see: https://github.com/microsoft/WSL/issues/11795#issuecomment-2235970146
2025-09-27 rename i2ccube -> oledmove
    最初は3Dキューブを表示したかったが、
    現状では単純な図形を上下左右に動かすだけなので改名。
2025-10-03 add codegen simulator (WIP)
2025-10-03 余分なファイルがブランチに含まれていたので修正削除
2025-10-06 RD, AD を用いたレジスタ割当て（WIP）
2025-10-06 リファクタ（WIP）
2025-10-07 リファクタ一旦完了
2025-10-08 アセンブラ生成途中のRDやADの状態を表示する
2025-10-08 Ershov 数を用いたコード生成シミュレータを追加
2025-10-09 ソースコードを構文解析して木構造を得る
2025-10-09 Ershov 数を用いたコード生成で複文をサポート
2025-10-09 ソースコードから3アドレスコードを得る
2025-10-09 追加し忘れていたファイルを追加
2025-10-09 テンポラリ変数の名前を登場順にする
2025-10-10 3アドレスコードを自動生成か直接与えるかを選択可能にする
2025-10-10 アセンブリ命令の型を ershov と simple で統一
2025-10-10 simple の結果表示を ershov に合わせる
2025-10-13 定数ロードに LD を使うバグを修正
2025-10-14 スピルするレジスタの決定に define-use 関係も利用
2025-10-14 ブロック出口で生存する変数を考慮したストア命令発行
2025-10-14 def-use の計算をリファクタ
2025-10-20 DOS用アプリをLinux上で動作可能にする
    とりあえずシステムコールのみエミュレーションする
    MMIOのエミュレーションはまだできていない
2026-01-26 シリアルコンソール開発のための環境を整備
2026-01-27 固定のDVI信号を出す（WIP）
    現状、ディスプレイには何も映らない
2026-01-28 黄色一色でディスプレイを塗る
2026-02-03 serial console for BuntanPC の回路と基板を追加
2026-02-03 画面をグラデーションで塗りつぶす
2026-02-05 基板設定を微修正
2026-02-05 デバッグ用ポートを削除
2026-02-05 fclkとpclkのクロックドメインを分ける
    将来の安全性向上のため
2026-02-05 00～7FのASCIIコードに対応した固定の文字列を表示する
2026-02-05 DVI信号生成の部分をモジュールに切り出す
2026-02-05 ソースコードにライセンス名と著作権帰属を表示
2026-02-05 CPUのuart.svをDVI出力回路に移植
    ついでにVerylに書き換え（動作未検証）
2026-02-06 sericonにUARTからの受信機能を追加（動作未検証）
2026-02-06 UART受信のバグを修正
2026-02-07 クロック同士を非同期に指定
    タイミング解析レポートの偽陽性を抑える
2026-02-07 時々UARTから受信ができないバグを修正
2026-02-08 LFで改行する
2026-02-13 sericonのUART受信データ化けを解消
2026-02-13 キャラクタLCD表示を停止＆DOSがUART3のみを使う
2026-02-19 デバッグコードを削除
2026-02-19 大きすぎる unsafe cdc ブロックを無くす
2026-02-20 表示が一周したときに古い内容を表示しない
2026-02-22 デバッグ用ポートの追加
2026-02-22 エスケープシーケンス CSI Pn G に対応
2026-02-23 新しい行に移動したときにRAMを1行分0クリアする
2026-02-23 1文字削除のエスケープシーケンスに対応
2026-02-23 マーカー方式の痕跡を削除
2026-02-24 エスケープシーケンス解析をリファクタ
2026-02-24 USB-UARTによるデバッグを可能にする
2026-02-24 DECSET, DECSTBMを認識
2026-02-24 edit.cが使うエスケープシーケンスに対応（WIP）
2026-02-26 カーソル移動に対応
    ついでにICHも一部実装
    ICHは本来右にずらす処理が必要だが、まだやっていない
2026-02-26 文字挿入によるスクロール処理の実装（WIP）
    scrn_memのRAM推論に失敗するのでDPX9Bを使うようにしたが挙動がおかしい
2026-03-29 人間が操作するオセロプログラムを追加
2026-03-29 1手のみ先読みの貪欲法オセロAIを搭載
2026-03-29 uccでコンパイル可能にするために変更
2026-03-29 BuntanPCアプリのエントリポイントをbuntan_mainへ変更
    Linux上でも同じコードを動かすために
    標準Cと競合しない名前にした
2026-03-30 オセロAIを追加（WIP）
2026-03-31 エスケープシーケンスを使ってオセロ盤面を見やすく表示
2026-03-31 盤面評価関数を実装（WIP）
2026-03-31 AIの思考時間を計測
2026-03-31 初期盤面に誤って石が描画されるバグを修正
2026-04-02 エスケープシーケンスCNL,CPL,ELを追加サポート
2026-04-06 CPUの単体テストのビルドが通るように修正
    ただし、一部のテストは失敗する
2026-04-06 CPUの単体テストを修正
2026-04-10 FPの最小値を保持するレジスタFPMINを追加
2026-04-12 min-maxで2手先読み
2026-04-12 othello.cにスタック使用量測定コードを追加
2026-04-18 オセロ盤面の座標を表示
2026-04-18 AIの手番をコマンドライン引数で指定する
2026-04-18 1手前の盤面を再表示する機能を追加
2026-04-18 棋譜記録＆表示
2026-04-19 foo[i][j]というような多重インデックスに対応
2026-04-19 fix ucc unit tests
2026-04-19 添字が 0 のときに無駄に add を発行しない
2026-04-19 オセロの棋譜をファイルに保存する機能を追加
2026-04-20 石の返し方のバグを修正
2026-04-22 ucc: PrintNodeがn->tokenを参照する前にNULLチェックするように
2026-04-22 ucc: main関数をbuntan_mainに移行したがtestがmainを要求して失敗していたので修正
2026-04-27 uasにリストファイル生成機能を追加
2026-04-27 dos.lstの生成ルールを追加
2026-04-30 バックパッチ後の機械語をリストファイルへ出力する
2026-04-30 RAM推論ではなくプリミティブを直接インスタンス化する（WIP）
2026-04-30 pmemの初期化をINIT_RAM_XXを用いて行う
2026-04-30 fix a bug of Makefile
2026-04-30 コメント修正
2026-04-30 SPLA/SPHAの挙動を変更
2026-04-30 RAM推論失敗の修正中（WIP）
2026-04-30 pc_rev1をコマンドラインでビルド可能にする
2026-04-30 DOSの動きが不可解、デバッグ出力
2026-04-30 dos.lstを無視
2026-04-30 CPUの動作周波数を20MHzに落とす & uasバグ修正
2026-05-01 uasにmapファイル生成機能を追加 & デバッグ用のスクリプトを追加
2026-05-02 実行トレース解析スクリプトに解析容易化オプションを搭載
2026-05-03 CPUを10MHzで動かす
2026-05-04 関数先頭アドレスのみ残すオプションを追加
2026-05-05 collapse-repeatsをuniqueとcollapse-repeatsの2段階にする
2026-05-06 関数の先頭アドレスとそこからのオフセットを表示
2026-05-08 uasバグ修正
    リストファイルを指定していない場合にSIGSEGVになるバグ
2026-05-08 AIが石を置けないときにパスする
2026-05-08 リファクタリング
    AIと人間の処理をそれぞれ関数として分離
2026-05-08 盤面が全部埋まったことを判定して終了する
2026-05-08 人間のパス機能を追加
2026-05-08 AIが石を置けるのにパスするバグを修正
2026-05-08 人間側パス自動判定
2026-05-20 ucc: tokenがnulのときとそうでないときの記述が冗長になっていた場所をリファクタリング
2026-05-22 bump DOS version date
2026-05-23 デバッグ情報を時分割で出力（4 clocks = 1 word）
2026-05-23 emulatorディレクトリにeditorconfigを追加
2026-05-23 emulatorのMakefileを作成
2026-05-23 cpu.c/hのテンプレを作成
2026-05-23 Makefileにverilogをcppにverilatorを使用して変換するワーカーを追加
2026-05-23 emulatorのcpu/ディレクトリとout/ディレクトリをignore二追加
2026-05-23 cpu.hにCPU初期化、リセット、ステップ、破棄関数の宣言のプロトタイプを追加
2026-05-23 Verilatorをちゃんとmakeするように
2026-05-23 del api.cpp
2026-05-23 簡易的にエミュレーションできるように？（多分？）
2026-05-23 spiがエミュレーションできた...？
2026-05-23 dosを読み込んで起動するように（ただし起動しない）
2026-05-23 dosがptyに書き出せるように
2026-05-23 ref spi.c
2026-05-23 デバッグ情報としてstack0の代わりにinsnを出す
2026-05-25 デバッグ情報として、pmem-addrに対応するアセンブリ言語コードを表示する
2026-05-25 dos.cの代わりにtestram.sを実行する
2026-05-25 testram.sのbuntan_mainを後ろにずらす
2026-05-26 dosにmain関数への対応を追加（エミュレーターを動作させるために）
2026-05-26 SDカードのやつがDOS側にデータを返せてないが一旦コミット
2026-05-26 SDカードの実装を拡張
2026-05-26 BSRAMのBLK_SELを使わなくする
2026-05-26 1024の倍のアドレスのときに正しく動かないバグを修正
2026-05-26 dos.cのデバッグ用印字を削除
2026-05-26 フォーマッターを追加
2026-05-26 CMD9を実装
2026-05-26 CMD17を実装し、DOSが起動してプロンプトが表示されるように
2026-05-26 debug()関数を追加し、.configを作成
2026-05-26 CPUを無限ループで回すように
2026-05-26 sd.imgを追加
2026-05-26 ホスト側のターミナルを動かさずにすべてDOSに吸わせるように
2026-05-26 stdinをいい感じに読み取れるように
2026-05-26 キーボード用ピンの設定をデバッグモードから通常モードへ
2026-05-26 ホストのキーボード入力から改行、BSにも対応
2026-05-26 正常にFAT16イメージになっていなかった（fat32になっていた）問題を修正
2026-05-26 ファイル書き込み(CMD24)二対応
2026-05-26 リファクタ（鬼）
2026-05-26 エミュレーターのreadmeを作成
2026-05-26 ほかファイルにも書かれていたSPDX-License-Identifier？を一応追加
2026-05-26 CPUクロックを27MHzに戻す
2026-05-26 decoderでラッチ推論を避け、組み合わせ回路にする
2026-05-26 ADC用125MHzクロックからsys_clkへのタイミング解析をしない
2026-05-27 sys_clk Fmax向上
    デコーダとそれ以降をレジスタで分割する
2026-05-28 4段階のフェーズを作る部分をワンホット化
    sys_clkのFmaxが27.009MHzに改善
2026-05-28 format bemu
2026-05-28 rename emulator to bemu
2026-05-28 src_a_sel を個別信号に分解（WIP）
2026-05-29 src_a_sel を個別信号に分解
    sys_clkのFmaxが27.267MHzに改善
2026-05-31 dos.cから必要ないmain関数を削除
2026-05-31 bemuをtemuに変更
2026-05-31 エミュレーター向けのDOSビルド時にmain関数をリンクするリンカをtemuに追加
2026-05-31 CPUが動作しないバグを修正
2026-05-31 del comments
2026-06-01 タイミング制約を満たすリファクタ
    Fmax が 26.898MHz から 27.212MHz に改善
2026-06-03 可変長引数に対応
2026-06-03 CPUシミュレーションをCPUの変更に対応
2026-06-03 fix: add buffer-length check in main.c
    The assembler uses strcpy to copy source lines into a fixed-size stack buffer 'line' without any bounds checking
2026-06-05 CPUのシミュレーションにVerilatorを使う (WIP)
2026-06-08 verilatorシミュレーションをuart outに対応
2026-06-08 シミュレーション時のCPUクロックを設定可能にする
2026-06-08 シミュレーション時のUARTのボーレートをCLOCK_HZに依存して決める
    そうしないと、CLOCK_HZの設定が小さいときに、UART送信が間に合わずシミュレーションがタイムアウトする
2026-06-08 Verilatorシミュレーションで信号のトレースを出力する
2026-06-08 MMIOの単体テストが成功するように修正
2026-06-09 UART 送信に uart モジュールを利用する
2026-06-16 無駄な add fp,0 を出力しない
2026-06-17 可変長引数のバグ修正（WIP）
    関数ポインタの引数に型を指定できるようにする
2026-06-17 引数が複数回参照されるときに誤って最適化されてしまうバグを修正
2026-06-18 ブロックを含む関数でのフレームサイズ計算をバックパッチする
2026-06-22 buntan_printf の実装とテストを追加
    %c, %d, %X にのみ対応
2026-06-22 othello.cを無改造でLinux向けにビルドできるようにする
2026-06-28 USBデバイスが接続されたらLEDを点灯させる
2026-06-28 forの型指定を除去 (#2516 への対応)
2026-06-28 USBデバイス検知後にバスリセット
2026-06-28 USB関連コードをusb_host.verylに抽出
2026-06-28 sericonにUSBデバイスが接続されたらLS,FSに応じてLEDを光らせる
2026-06-29 Verylの前方参照エラーの解消
2026-06-30 1msごとに反転するtick_toggle信号を追加したが常に0になってしまう
