# Repository buntan-pc/buntan-pc

File README.md:

# buntan-pc
BuntanPC は CPU・OS・言語処理系を手作りするプロジェクトです

## プロジェクトの目的
プロジェクトの主目的はオリジナルのコンピュータを作り上げることです。
その過程で CPU、OS、コンパイラ、アセンブラ、リンカ等の作り方を学ぶという副目的もあります。

最終的に BuntanPC で文書作成や Web 閲覧、ロボット制御、プログラミングなどをしたいです。

開発は当面パソコン上で行い、ビルド済みプログラムを転送して実行しますが、
最終的には BuntanPC 上で BuntanPC 向けのアプリを開発したいです。

### マイルストーン
[プロジェクトの中間目標](./doc/milestone.md) には展示会やイベントなどを対象とした開発目標を記します。

## 名前の由来
柑橘類の「文旦（ぶんたん）」と、役割「分担」して作るという意味を掛けています。

PC は Pocket Computer もしくは Personal Computer の略です。
最初はきっとポケコン的な見た目や機能になると思います。
最終的にパソコンが作れたら楽しいですね。

## ライセンス
buntan-pc リポジトリに含まれるソースコードやドキュメントは、別に定めがない限り MIT ライセンスとします。
ライセンス文書 [LICENSE](./LICENSE) にしたがってご利用ください。

## ビルド・実行
実際のビルド方法が決まったらここに書きます。

当面は CPU と OS は BuntanPC Board で動かし、コンパイラ等の言語処理系はパソコン上で動かすことを想定しています。

## BuntanPC Board
BuntanPC を動かすための実機です。
オリジナルのプリント基板を使ったポケコン風の装置で、キーボードや表示装置を持ちます。

プリント基板の提供方法は未定です。決まったら書きます。

## KiCad design sericon/devboard_rev1/devboard_rev1.kicad_pcb

File sericon/README.md:

# BuntanPC 用シリアルコンソール

ファイル構成

    controller_rev1/    メインコントローラ（Tang Nano 9K）のソースコードなど

Parts:
C1: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J2: 5075AR-04-WH; USB_A_Neltron_5075AR-04
J3: Conn_Grove_Dev; Grove_1x04_P2mm_THT_Horizontal
J4, J5: Conn_02x24_Odd_Even; PinHeader_2x24_P2.54mm_Vertical
R1, R2: 15k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: Tang_nano_9K; DIP-48_Tang-Nano-9K
U2: TCK107AF; SOT-23-5_HandSoldering

Connections:
+5V: C1.1, J2.1 (VBUS), J3.3 (VCC), J5.35, U1.31 (5V), U2.5 (VIN)
/scl: J4.26, U1.13 (PIN40_IOB33B)
/sda: J4.28, U1.14 (PIN35_IOB29A)
/uart2_rx: J4.32, U1.16 (PIN42_IOB41B)
/uart2_tx: J4.30, U1.15 (PIN41_IOB41A)
/uart3b_rx: J3.2 (TX), J5.39, U1.29 (PIN49_IOR24A)
/uart3b_tx: J3.1 (RX), J5.37, U1.30 (PIN48_IOR24B)
/uart_rx: J4.38, U1.19 (PIN54_IOR15A)
/uart_tx: J4.36, U1.18 (PIN53_IOR15B)
/usb_dm: J1.2 (D-), J5.21, R2.1, U1.38 (PIN76_IOT37B)
/usb_dp: J1.3 (D+), J5.19, R1.1, U1.39 (PIN77_IOT37A)
/vbus_ctrl: J5.1, U1.48 (PIN63_IOR5A), U2.3 (CTRL)
GND: C1.2, J1.4 (GND), J1.5 (Shield), J2.4 (GND), J2.5 (Shield), J3.4 (GND), J4.1, J4.3, J4.5, J4.7, J4.9, J4.11, J4.13, J4.15, J4.17, J4.19, J4.21, J4.23, J4.25, J4.27, J4.29, J4.31, J4.33, J4.35, J4.37, J4.39, J4.41, J4.43, J4.45, J4.47, J5.2, J5.4, J5.6, J5.8, J5.10, J5.12, J5.14, J5.16, J5.18, J5.20, J5.22, J5.24, J5.26, J5.28, J5.30, J5.32, J5.34, J5.36, J5.38, J5.40, J5.42, J5.44, J5.45, J5.46, J5.48, R1.2, R2.2, U1.26 (GND), U2.2 (GND)
unnamed: J1.1 (VBUS), U2.1 (VOUT)
unnamed: J4.2, U1.1 (PIN38_IOB31B)
unnamed: J4.4, U1.2 (PIN37_IOB31A)
unnamed: J4.6, U1.3 (PIN36_IOB29B)
unnamed: J4.8, U1.4 (PIN39_IOB33A)
unnamed: J4.10, U1.5 (PIN25_IOB8A)
unnamed: J4.12, U1.6 (PIN26_IOB8B)
unnamed: J4.14, U1.7 (PIN27_IOB11A)
unnamed: J4.16, U1.8 (PIN28_IOB11B)
unnamed: J4.18, U1.9 (PIN29_IOB13A)
unnamed: J4.20, U1.10 (PIN30_IOB13B)
unnamed: J4.22, U1.11 (PIN33_IOB23A)
unnamed: J4.24, U1.12 (PIN34_IOB23B)
unnamed: J4.34, U1.17 (PIN51_IOR17B)
unnamed: J4.40, U1.20 (PIN55_IOR14B)
unnamed: J4.42, U1.21 (PIN56_IOR14A)
unnamed: J4.44, U1.22 (PIN57_IOR13A)
unnamed: J4.46, U1.23 (PIN68_IOT42B)
unnamed: J4.48, U1.24 (PIN69_IOT42A)
unnamed: J5.3, U1.47 (PIN86_IOT8A)
unnamed: J5.5, U1.46 (PIN85_IOT8B)
unnamed: J5.7, U1.45 (PIN84_IOT10A)
unnamed: J5.9, U1.44 (PIN83_IOT10B)
unnamed: J5.11, U1.43 (PIN82_IOT11A)
unnamed: J5.13, U1.42 (PIN81_IOT11B)
unnamed: J5.15, U1.41 (PIN80_IOT12A)
unnamed: J5.17, U1.40 (PIN79_IOT12B)
unnamed: J5.23, U1.37 (PIN75_IOT38A)
unnamed: J5.25, U1.36 (PIN74_IOT38B)
unnamed: J5.27, U1.35 (PIN73_IOT39A)
unnamed: J5.29, U1.34 (PIN72_IOT39B)
unnamed: J5.31, U1.33 (PIN71_IOT41A)
unnamed: J5.33, U1.32 (PIN70_IOT41B)
unnamed: J5.41, U1.28 (PIN31_IOB15A)
unnamed: J5.43, U1.27 (PIN32_IOB15B)
unnamed: J5.47, U1.25 (3V3)

Notes on the sheet:
ADC
key_row
GroveのRX/TXは ホストからみた名前
LCD
key_col_n
キーボード用 USBコネクタ
HDMI
HDMIディスプレイ 電源供給用 USBコネクタ

Board: 2 copper layers, 75.0 x 80.0 mm, 14 parts (0 on the bottom side), 49 nets.

## KiCad design board/io-probe-adapter_rev1/io-probe-adapter_rev1.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J2: Conn_02x24_Odd_Even; PinHeader_2x24_P2.54mm_Vertical
U1: Tang_nano_9K; DIP-48_Tang-Nano-9K

Connections:
GND: J1.1, J1.3, J1.5, J1.7, J1.9, J1.11, J1.13, J1.15, J1.17, J1.19, J1.21, J1.23, J1.25, J1.27, J1.29, J1.31, J1.33, J1.35, J1.37, J1.39, J1.41, J1.43, J1.45, J1.47, J2.2, J2.4, J2.6, J2.8, J2.10, J2.12, J2.14, J2.16, J2.18, J2.20, J2.22, J2.24, J2.26, J2.28, J2.30, J2.32, J2.34, J2.36, J2.38, J2.40, J2.42, J2.44, J2.45, J2.46, J2.48, U1.26 (GND)
unnamed: J1.2, U1.1 (PIN38_IOB31B)
unnamed: J1.4, U1.2 (PIN37_IOB31A)
unnamed: J1.6, U1.3 (PIN36_IOB29B)
unnamed: J1.8, U1.4 (PIN39_IOB33A)
unnamed: J1.10, U1.5 (PIN25_IOB8A)
unnamed: J1.12, U1.6 (PIN26_IOB8B)
unnamed: J1.14, U1.7 (PIN27_IOB11A)
unnamed: J1.16, U1.8 (PIN28_IOB11B)
unnamed: J1.18, U1.9 (PIN29_IOB13A)
unnamed: J1.20, U1.10 (PIN30_IOB13B)
unnamed: J1.22, U1.11 (PIN33_IOB23A)
unnamed: J1.24, U1.12 (PIN34_IOB23B)
unnamed: J1.26, U1.13 (PIN40_IOB33B)
unnamed: J1.28, U1.14 (PIN35_IOB29A)
unnamed: J1.30, U1.15 (PIN41_IOB41A)
unnamed: J1.32, U1.16 (PIN42_IOB41B)
unnamed: J1.34, U1.17 (PIN51_IOR17B)
unnamed: J1.36, U1.18 (PIN53_IOR15B)
unnamed: J1.38, U1.19 (PIN54_IOR15A)
unnamed: J1.40, U1.20 (PIN55_IOR14B)
unnamed: J1.42, U1.21 (PIN56_IOR14A)
unnamed: J1.44, U1.22 (PIN57_IOR13A)
unnamed: J1.46, U1.23 (PIN68_IOT42B)
unnamed: J1.48, U1.24 (PIN69_IOT42A)
unnamed: J2.1, U1.48 (PIN63_IOR5A)
unnamed: J2.3, U1.47 (PIN86_IOT8A)
unnamed: J2.5, U1.46 (PIN85_IOT8B)
unnamed: J2.7, U1.45 (PIN84_IOT10A)
unnamed: J2.9, U1.44 (PIN83_IOT10B)
unnamed: J2.11, U1.43 (PIN82_IOT11A)
unnamed: J2.13, U1.42 (PIN81_IOT11B)
unnamed: J2.15, U1.41 (PIN80_IOT12A)
unnamed: J2.17, U1.40 (PIN79_IOT12B)
unnamed: J2.19, U1.39 (PIN77_IOT37A)
unnamed: J2.21, U1.38 (PIN76_IOT37B)
unnamed: J2.23, U1.37 (PIN75_IOT38A)
unnamed: J2.25, U1.36 (PIN74_IOT38B)
unnamed: J2.27, U1.35 (PIN73_IOT39A)
unnamed: J2.29, U1.34 (PIN72_IOT39B)
unnamed: J2.31, U1.33 (PIN71_IOT41A)
unnamed: J2.33, U1.32 (PIN70_IOT41B)
unnamed: J2.35, U1.31 (5V)
unnamed: J2.37, U1.30 (PIN48_IOR24B)
unnamed: J2.39, U1.29 (PIN49_IOR24A)
unnamed: J2.41, U1.28 (PIN31_IOB15A)
unnamed: J2.43, U1.27 (PIN32_IOB15B)
unnamed: J2.47, U1.25 (3V3)

Board: 2 copper layers, 78.7 x 83.8 mm, 7 parts (0 on the bottom side), 48 nets.

## KiCad design board/pc_rev2/pcb/pc_rev2.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Conn_02x13_Odd_Even; PinHeader_2x14_P2.54mm_Vertical
J2: Conn_02x08_Row_Letter_Last; PinHeader_2x08_P2.54mm_Vertical
J3: Conn_02x06_Row_Letter_Last; PinHeader_2x06_P2.54mm_Vertical
J4: Conn_02x10_Row_Letter_Last; PinHeader_2x10_P2.54mm_Vertical
J5: Conn_Grove_Host; Grove_1x04_P2mm_THT_Horizontal
J6, J7: Conn_01x03; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J8, J9: Conn_Grove-Analog_Host; Grove_1x04_P2mm_THT_Horizontal
J10: Conn_01x05; PinHeader_1x03_P2.54mm_Vertical
J11, J14, J20, J23: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J22: Conn_Grove_I2C; Grove_1x04_P2mm_THT_Horizontal
LS1: 13mm; Buzzer_Murata_PKM13EPYH4000-A0_D12.6mm_H6.9mm; Manufacturer PN PKM13EPYH4000-A0
R1: 0.5M; R_LDR_D6.4mm_P3.4mm_Vertical; Manufacturer PN GL5516
RV1: 20k; Potentiometer_Suntan_TSR-3386K_Vertical; Manufacturer PN TSR-3386K-EY5-203TR
RV2: 10k; Potentiometer_Suntan_TSR-3386K_Vertical; Manufacturer PN TSR-3386K-EY5-103TR
U2: SKU2782

Connections:
+3.3V: J11.3, J14.3, J23.3, R1.1; also elsewhere on the board
+5V: J5.3 (VCC), J11.1, J14.1, J23.1; also elsewhere on the board
/ADC/ain0: R1.2, RV2.1; also elsewhere on the board
/ADC/ain2: J8.1 (A0); also elsewhere on the board
/ADC/ain3: J8.2 (A1); also elsewhere on the board
/ADC/ain4: J9.1 (A0); also elsewhere on the board
/ADC/ain5: J9.2 (A1); also elsewhere on the board
/ADC/ain_buf: J10.3; also elsewhere on the board
/ADC/cmp: J1.20; also elsewhere on the board
/ADC/dac_out: J10.2; also elsewhere on the board
/ADC/sel0: J1.22; also elsewhere on the board
/ADC/sel1: J1.24; also elsewhere on the board
/ADC/sel2: J1.26; also elsewhere on the board
/ADC/sh_buf: J10.1; also elsewhere on the board
/ADC/sh_on: J1.18; also elsewhere on the board
/ADC/vref_d0: J1.2; also elsewhere on the board
/ADC/vref_d1: J1.4; also elsewhere on the board
/ADC/vref_d2: J1.6; also elsewhere on the board
/ADC/vref_d3: J1.8; also elsewhere on the board
/ADC/vref_d4: J1.10; also elsewhere on the board
/ADC/vref_d5: J1.12; also elsewhere on the board
/ADC/vref_d6: J1.14; also elsewhere on the board
/ADC/vref_d7: J1.16; also elsewhere on the board
/audio/mic_in: J6.1; also elsewhere on the board
/audio/spk_on: J1.28; also elsewhere on the board
/audio/spk_out: J7.1; also elsewhere on the board
/beep: J2.14, RV1.1; also elsewhere on the board
/mcu/dbgio0: J4.2; also elsewhere on the board
/mcu/dbgio1: J4.4; also elsewhere on the board
/mcu/dbgio2: J4.6; also elsewhere on the board
/mcu/gpio0: J2.2; also elsewhere on the board
/mcu/gpio1: J2.4; also elsewhere on the board
/mcu/gpio2: J2.6; also elsewhere on the board
/mcu/gpio3: J2.8; also elsewhere on the board
/mcu/gpio4: J2.10; also elsewhere on the board
/mcu/gpio5: J2.12; also elsewhere on the board
/mcu/gpio7: J2.16; also elsewhere on the board
/mcu/rgbled: J4.12; also elsewhere on the board
/mcu/tf_cs: J4.14; also elsewhere on the board
/mcu/tf_miso: J4.16; also elsewhere on the board
/mcu/tf_mosi: J4.20; also elsewhere on the board
/mcu/tf_sclk: J4.18; also elsewhere on the board
/msmp_rx: J3.5; also elsewhere on the board
/msmp_tx: J3.7; also elsewhere on the board
/scl: J4.10, J22.1 (SCL); also elsewhere on the board
/sda: J4.8, J22.2 (SDA); also elsewhere on the board
/sericon_rx: J3.9, J5.1 (RX); also elsewhere on the board
/sericon_tx: J3.11, J5.2 (TX); also elsewhere on the board
/uart_rx: J3.1, U2.3 (TxD); also elsewhere on the board
/uart_tx: J3.3, U2.2 (RxD); also elsewhere on the board
GND: J1.1, J1.3, J1.5, J1.7, J1.9, J1.11, J1.13, J1.15, J1.17, J1.19, J1.21, J1.23, J1.25, J1.27, J2.1, J2.3, J2.5, J2.7, J2.9, J2.11, J2.13, J2.15, J3.2, J3.4, J3.6, J3.8, J3.10, J3.12, J4.1, J4.3, J4.5, J4.7, J4.9, J4.11, J4.13, J4.15, J4.17, J4.19, J5.4 (GND), J6.2, J7.2, J8.4 (GND), J9.4 (GND), J20.1, J20.2, J20.3, J22.4 (GND), LS1.2, RV1.3, RV2.2, RV2.3, U2.6 (GND); also elsewhere on the board
unnamed: J8.3 (VCC), J11.2
unnamed: J9.3 (VCC), J14.2
unnamed: J22.3 (VCC), J23.2
unnamed: LS1.1, RV1.2

Notes on the sheet:
デジタル
アナログ
GroveのRX/TXは ホストからみた名前
設計メモ 秋月電子 AE-TTL-232R SwitchScience SKU 2782 どちらも使用可能

Parts:
C14: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: 1N4148; D_DO-34_SOD68_P7.62mm_Horizontal
J15: INPUT; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
J16: OUTPUT; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
J21: Conn_Grove_Host; Grove_1x04_P2mm_THT_Horizontal
R33: 390; R_Axial_CF25_CFS50_L6.3mm_D2.3mm_P7.62mm_Horizontal; Manufacturer PN CF25J390RB
R34: 33; R_Axial_CF25_CFS50_L6.3mm_D2.3mm_P7.62mm_Horizontal; Manufacturer PN CFS50J33RB
R35: 10; R_Axial_CF25_CFS50_L6.3mm_D2.3mm_P7.62mm_Horizontal; Manufacturer PN CF25J10RB
R36: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U9: TLP2361; SO-5-6_4.55x3.7mm_P1.27mm

Connections:
+3.3V: C14.1, R34.1, U9.6 (VDD); also elsewhere on the board
+5V: J21.3 (VCC); also elsewhere on the board
/msmp_rx: J21.1 (RX), R36.2; also elsewhere on the board
/msmp_tx: J21.2 (TX), R35.1; also elsewhere on the board
GND: C14.2, J16.3, J21.4 (GND), U9.4 (GND); also elsewhere on the board
unnamed: D1.2 (A), J15.2, U9.3 (K)
unnamed: D1.1 (K), R33.2, U9.1 (A)
unnamed: J15.1, R33.1
unnamed: J16.1, R34.2
unnamed: J16.2, R35.2
unnamed: R36.1, U9.5 (VO)

Notes on the sheet:
SIG_{TX}
出力電流I_{O}の 絶対最大定格は10mA
V_{TX}
抵抗選択表（いずれも精度5%品でOK）
R4、R5は100Ω×3で33Ωを代用する場合に実装
VDD 5V 3.3V R33 390Ω/0.25W 390Ω/0.25W R34 220Ω/0.25W 33Ω/0.5W R35 220Ω/0.25W 10Ω/0.25W
設計メモ J15はMSMP受信コネクタ、J16は送信。 MSMPの物理規格はMIDIと同様のカレントループ。 3.3Vの場合、33+390+10Ω=433ΩでLEDが駆動される。 TLP2361発光部のVFは1.5V(typ)なのでIF=(3.3-1.5)/433=4.16mA TLP2361発光部の推奨動作条件2～6mAに収まる。

Parts:
C1, C2, C3, C7, C8, C17: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4: 2000pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9: 470uF; CP_Radial_D8.0mm_P3.50mm
C18: 10nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D2: BAT54S; SOT-23; Manufacturer PN BAT54SLT1G
J12, J17: GND Pins; PinHeader_1x02_P2.54mm_Vertical
J13, J19: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J18: Conn_01x05; PinHeader_1x03_P2.54mm_Vertical
Q1: BC817BPN; SOT-457T
R2, R8: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4, R5, R9, R10, R11, R37: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6: 20k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7: 200; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12, R13: 33; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14, R15, R16, R38: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RV3: 50k; Potentiometer_Suntan_TSR-3386K_Vertical; Manufacturer PN TSR-3386K-EY5-503TR
U3: LMV324B; TSSOP-14_4.4x5mm_P0.65mm; Manufacturer PN LMV324B-TR
U5: TC74HC4066AF; SO-14_5.3x10.2mm_P1.27mm

Connections:
+3.3V: D2.2 (K), R2.1, R3.1; also elsewhere on the board
+5V: C3.2, C17.2, Q1.6 (C1), R9.1, U3.4 (V+); also elsewhere on the board
/ADC/dac_out: U5.1; also elsewhere on the board
/audio/mic_in: C2.1, R2.2; also elsewhere on the board
/audio/mic_mid: C4.2, J13.2, R6.2, U3.10 (+), U3.14
/audio/mic_opin: C2.2, J13.1, R5.1, U3.12 (+)
/audio/mic_out: D2.3 (COM), J19.1, R38.2; also elsewhere on the board
/audio/spk_mid: J18.2, R12.1, R13.1, U3.7
/audio/spk_on: U5.13; also elsewhere on the board
/audio/spk_opin: C8.2, J18.1, R11.1, R16.1
/audio/spk_opout: C9.1, J18.3, Q1.1 (E1), Q1.4 (E2), R14.2
/audio/spk_out: C9.2, R15.1; also elsewhere on the board
GND: C1.2, C3.1, C5.2, C6.2, C7.2, C17.1, C18.2, D2.1 (A), J12.1, J12.2, J17.1, J17.2, J19.2, Q1.3 (C2), R4.2, R10.2, R15.2, U3.11 (V-); also elsewhere on the board
GNDREF: R5.2, R37.2, U3.1, U3.2 (-)
unnamed: C5.1, R7.2
unnamed: C6.1, R8.2
unnamed: C7.1, R9.2, R10.1, R11.2
unnamed: C8.1, C18.1, R37.1, U5.2
unnamed: Q1.2 (B1), R12.2
unnamed: Q1.5 (B2), R13.2
unnamed: R38.1, RV3.3, U3.8
unnamed: C1.1, R3.2, R4.1, U3.3 (+)
unnamed: R16.2, U3.5 (+)
unnamed: R14.1, U3.6 (-)
unnamed: R8.1, RV3.1, RV3.2, U3.9 (-)
unnamed: C4.1, R6.1, R7.1, U3.13 (-)

Notes on the sheet:
2.5V
1.65V
設計メモ U3Cの出力が5Vのとき、D2のIF≦(5-3.3)/10k=0.17mA onsemi BAT54SLはIF=1mAでVF=0.32V(max) したがってmic_out≦3.3+0.32V U8(TC74HC4051AF)のIO入力定格-0.5V～VCC+0.5Vを満たす。
設計メモ スピーカーのインピーダンスが8Ω、 C_{9}=470μFのとき、カットオフ周波数は42.3Hz
設計メモ C18はポップノイズ防止用。 無し、10nF～100nFで実験。
設計メモ 高域 -3dB カットオフ周波数 f_{CH} f_{CH} = 1/(2πC_{4}R_{6}) = 3.98kHz
設計メモ spk_inは0V～3.3V（1.65V±1.65V） それを0.85V～4.15V（2.5V±1.65V） にシフトさせ、出力を最大化する。 3PEAKのLMV324Bは入力と出力がRail-to-Rail
設計メモ mic_inにはWM-61A相当のECM XCM6035-2022-354Rを接続予定。

Parts:
C10, C12, C13, C15, C16: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C11: 100pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R17, R19, R21, R23, R25, R27, R29, R31, R32: 22k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R18, R20, R22, R24, R26, R28, R30: 11k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U4: LMV324B; TSSOP-14_4.4x5mm_P0.65mm; Manufacturer PN LMV324B-TR
U5: TC74HC4066AF; SO-14_5.3x10.2mm_P1.27mm
U6: TPCMP231; SOT-23-5; Manufacturer PN TPCMP231-S5TR
U8: 74HC4051; SOIC-16W_5.3x10.2mm_P1.27mm; Manufacturer PN TC74HC4051AF(EL,F)
U10: MCP1501-30xCH; SOT-23-6

Connections:
+3.3V: C10.1, C12.1, C16.1, U5.14 (VDD), U6.5 (V+), U8.16 (VCC); also elsewhere on the board
+5V: C13.2, C15.1, U4.4 (V+), U10.4 (~SHDN), U10.6 (VDD); also elsewhere on the board
/ADC/ain0: U8.13 (A0); also elsewhere on the board
/ADC/ain2: U8.15 (A2); also elsewhere on the board
/ADC/ain3: U8.12 (A3); also elsewhere on the board
/ADC/ain4: U8.1 (A4); also elsewhere on the board
/ADC/ain5: U8.5 (A5); also elsewhere on the board
/ADC/ain_buf: U4.8, U4.9 (-), U5.3; also elsewhere on the board
/ADC/cmp: U6.1; also elsewhere on the board
/ADC/dac_out: U4.13 (-), U4.14, U8.2 (A6); also elsewhere on the board
/ADC/dac_raw: R17.2, R18.2, U4.12 (+), U6.4 (-)
/ADC/sel0: U8.11 (S0); also elsewhere on the board
/ADC/sel1: U8.10 (S1); also elsewhere on the board
/ADC/sel2: U8.9 (S2); also elsewhere on the board
/ADC/sh_buf: U4.1, U4.2 (-), U6.3 (+); also elsewhere on the board
/ADC/sh_on: U5.5; also elsewhere on the board
/ADC/vref_d0: R31.1; also elsewhere on the board
/ADC/vref_d1: R29.1; also elsewhere on the board
/ADC/vref_d2: R27.1; also elsewhere on the board
/ADC/vref_d3: R25.1; also elsewhere on the board
/ADC/vref_d4: R23.1; also elsewhere on the board
/ADC/vref_d5: R21.1; also elsewhere on the board
/ADC/vref_d6: R19.1; also elsewhere on the board
/ADC/vref_d7: R17.1; also elsewhere on the board
/audio/mic_out: U8.14 (A1); also elsewhere on the board
GND: C10.2, C11.2, C12.2, C13.1, C15.2, C16.2, R32.1, U4.5 (+), U4.11 (V-), U5.6, U5.7 (VSS), U5.8, U5.9, U5.10, U5.11, U5.12, U6.2 (V-), U8.6 (~E), U8.7 (VEE), U8.8 (GND), U10.2 (GND), U10.3 (GND), U10.5 (GND); also elsewhere on the board
unnamed: R18.1, R19.2, R20.2
unnamed: R20.1, R21.2, R22.2
unnamed: R22.1, R23.2, R24.2
unnamed: R24.1, R25.2, R26.2
unnamed: R26.1, R27.2, R28.2
unnamed: R28.1, R29.2, R30.2
unnamed: R30.1, R31.2, R32.2
unnamed: C11.1, U4.3 (+), U5.4
unnamed: U4.6 (-), U4.7
unnamed: U4.10 (+), U8.3 (A)
unnamed: U8.4 (A7), U10.1 (OUT)

Notes on the sheet:
3.0V
S&H制御 H=3.3V
S&H
アナログ入力 0V～3.3V
CMP出力
プッシュプル出力 レールツーレール出力
設計メモ R-2R DACには1%精度のチップ抵抗を用いる。 8ビットDACに本来必要な精度には足りないが、 このDACは動作原理を説明するためのものなので問題無い。
